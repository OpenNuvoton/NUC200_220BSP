# Keil uVision project ISP_RS485.uvproj, settings and files
target ISP_RS485 (6160000::V6.16::ARMCLANG)
  device: NUC220VE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: NUC200_220_ISP_RS485_PB4_PB5_PB6
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC200Series\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC200Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC200Series/Source/: system_NUC200Series.c
    ../../../../Library/Device/Nuvoton/NUC200Series/Source/ARM/: startup_NUC200Series.s
  group User
    ../: FMC_USER.c ISP_USER.c main.c targetdev.c uart_transfer.c
