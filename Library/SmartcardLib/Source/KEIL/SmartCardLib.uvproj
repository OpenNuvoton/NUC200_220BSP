# Keil uVision project SmartCardLib.uvproj, settings and files
target SmartCardLib (ARM-ADS)
  device: NUC220VE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: SmartCardLib +hex (library)
  AfterMake: cmd.exe /C copy /Y obj\SmartCardLib.lib ..\..\SmartCardLib_Keil.lib
  c flags: OneElfS=1
  c include: ..\..\..\CMSIS\Include;..\..\..\Device\Nuvoton\NUC200Series\Include;..\..\..\StdDriver\inc;..\..\..\SmartcardLib\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source
    ../: sclib_util.c sclib_api.c sclib_t0protocol.c sclib_t1protocol.c
