# IAR project Backup of SmartCardLib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: NUC200AE series Nuvoton NUC200AE series (NUC230AE,NUC240AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\NUC200Series\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  postbuild: cmd.exe /C copy /Y "Debug\Exe\SmartCardLib.a" "..\..\SmartCardLib_IAR.a"
  ILINK.IlinkOutputFile: SmartCardLib.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..; ..\..\..\Device\Nuvoton\NUC200Series\Include; ..\..\..\StdDriver\inc; ..\..\..\CMSIS\Include
  postbuild: cmd.exe /C copy /Y "Release\Exe\SmartCardLib.a" "..\..\SmartCardLib_IAR.a"
  group Source Files
    ../: sclib_api.c sclib_t0protocol.c sclib_t1protocol.c sclib_util.c
